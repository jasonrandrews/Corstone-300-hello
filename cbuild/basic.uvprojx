# Keil uVision project basic.uvprojx, settings and files
target Debug (6140001::V6.14.1::ARMCLANG)
  device: SSE-300-MPS2 ARM
  pack: ARM.V2M_MPS2_SSE_300_BSP.1.0.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28000000,0x00200000) IROM(0x10000000,0x00040000) IROM2(0x00000000,0x00040000) XRAM(0x38200000,0x00200000) XRAM2(0x28200000,0x00200000) XRAM3(0x31000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: CMSIS-RV2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  asm include: .\RTE\_Debug
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28000000 size 0x200000
  scatter file: .\RTE\Device\ARMCM55\ARMCM55_ac6.sct
  group Documents
    ./: Abstract.txt
  group Source
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
